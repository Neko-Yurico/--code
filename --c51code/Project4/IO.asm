ORG 0000H
	LJMP MAIN
	
	ORG 0100H
		MAIN: MOV A,#0
		MOV R2,#8
		MOV R0,#50H
		LOOP: MOV @R0,A
		INC R0
		INC A
		DJNZ R2,LOOP
		LOOP1:LCALL DISPLAY
		SJMP LOOP1
		SJMP $
			DISPLAY:MOV R0,#57H
			MOV R3,#7FH
			MOV A,R3
			LD0: MOV P2,A
			MOV A,@R0
			ADD A,#0EH
			MOVC A,@A+PC
			MOV P0,A
			ACALL DL1
			DEC R0
			MOV A,R3
			JNB ACC.0,LD1
			RR A
			MOV R3,A
			AJMP LD0
			LD1: RET
			TAB: DB 3FH,06H,5BH,4FH,66H,6DH,7DH,07H
				DB 7FH,6FH,77H,39H,5EH,79H,71H
					DL1: MOV R7,#02H
					DL: MOV R6,#0FFH
					DL0: DJNZ R6,DL0
					DJNZ R7,DL
					RET
					END